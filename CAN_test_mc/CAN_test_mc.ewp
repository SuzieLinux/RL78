# IAR project CAN_test_mc.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F104BG RL78 - R5F104BG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCDiagSuppress: Pe188
  ICCRL78.CCIncludePath2: src\Base; src\can; src\Rtk; src\spi
  OBJCOPY.OOCOutputFile: CAN_test_mc.srec
  ILINK.IlinkOutputFile: CAN_test_mc.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  group (top)
    src/can/: dcan.c pcan.c
    src/Base/: main.c r_cg_cgc.c r_cg_cgc_user.c r_cg_port.c r_systeminit.c
    src/Rtk/: r_cg_it.c RtkSched.c RtkTasks.c
    src/spi/: spi.c

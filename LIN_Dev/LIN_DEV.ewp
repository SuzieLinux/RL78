# IAR project LIN_DEV.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F1056A RL78 - R5F1056A
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: src\generated; src\lin; src\Rtk; src; src\vfd
  ILINK.IlinkOutputFile: LIN_DEV.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  group (top)
    src/lin/: lin.c
    src/: main.c
    src/generated/: r_cg_adc.c r_cg_adc_user.c r_cg_cgc.c r_cg_cgc_user.c r_cg_intp.c r_cg_intp_user.c r_cg_pfdl.c r_cg_port.c r_cg_port_user.c r_cg_sau.c r_cg_sau_user.c r_cg_systeminit.c r_cg_tau.c r_cg_tau_user.c
    src/Rtk/: RtkSched.c RtkTasks.c
    src/vfd/: vfd.c

# IAR project csi_test.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F104BG RL78 - R5F104BG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCDiagSuppress: Pe188
  ICCRL78.CCIncludePath2: src\Base; src\can; src\tasks; src\spi
  OBJCOPY.OOCOutputFile: csi_test.srec
  ILINK.IlinkOutputFile: csi_test.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  group (top)
    src/can/: dcan.c pcan.c
    src/Base/: main.c r_cg_cgc.c r_cg_cgc_user.c r_cg_port.c r_systeminit.c
    src/tasks/: r_cg_it.c Scheduler.c Tasks.c
    src/spi/: spi.c
